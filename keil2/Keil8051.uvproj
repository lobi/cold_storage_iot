# Keil uVision project Keil8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keil8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.h dht.h dht11.h eeprom.h I2C.h LCD8bit.h UART.h utils.h DataAccess.h

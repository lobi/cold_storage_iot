# Keil uVision project eeprom_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: eeprom_lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c I2C.h delay.h LCD8bit.h UART.h utils.h dht11.h LCD16x2_DHT11.h
